# IAR project pedometer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52840_xxAA NordicSemi nRF52840_xxAA
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NRF52840_XXAA
  ICCARM.CCIncludePath2: ..\..\..\drivers\adxl362; ..\; ..\algorithm\; ..\..\..\..\components\libraries\log\src; ..\..\..\..\components\libraries\log; ..\..\..\..\components\libraries\util; ..\..\..\..\modules\nrfx\mdk; ..\..\..\..\components\softdevice\s140\headers; ..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\components\libraries\strerror; ..\..\..\app\nRF52840_app; ..\..\..\..\components\libraries\memobj; ..\..\..\..\components\libraries\balloc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: pedometer.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; NRF52840_XXAA
  ICCARM.CCOptLevel: 3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: pedometer.c
  group algorithm
    ../algorithm/: hip_algorithm.c
