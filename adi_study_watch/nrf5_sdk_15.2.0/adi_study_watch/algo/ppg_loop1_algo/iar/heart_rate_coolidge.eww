<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\heart_rate_coolidge.ewp</path>
    </project>
    <batchBuild />
</workspace>


