# IAR project heart_rate_coolidge.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52840_xxAA NordicSemi nRF52840_xxAA
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ADUCM3029; DETECTION_GREEN_LED; HRMPLUS; STATIC_AGC; AGC_FEATURE; NRF52840_XXAA; NRF_LOG; HRV; TIA_SAT_REG
  ICCARM.CCIncludePath2: ..\..\..\drivers\adpd4000; ..\; ..\ppg_motion_reject_algo; ..\..\sqi\package\; ..\..\hrv\; ..\..\..\..\components\libraries\log\src; ..\..\..\..\components\libraries\log; ..\..\..\..\components\libraries\util; ..\..\..\..\modules\nrfx\mdk; ..\..\..\..\components\softdevice\s140\headers; ..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\components\libraries\strerror; ..\..\..\app\nRF52840_app; ..\..\..\..\components\libraries\memobj; ..\..\..\..\components\libraries\balloc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  prebuild: cmd /c "copy /Y ..\adpd400x_lib.h  ..\package\adpd400x_lib.h"
  postbuild: cmd /c "cd ..\package & makelib.cmd debug AGClibM4_Debug.a ..\..\sqi\iar\package\Debug\libadi_vsm_sqi_m4f_Debug.a ..\..\hrv\libadi_vsm_hrv_m4f.a lib_adi_vsm_hrm_m3.a lib_adi_vsm_toolbox_m3.a & del debug\lib_adpd_m4.a"
  ILINK.IlinkOutputFile: HeartRateCoolidge.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADUCM3029; DETECTION_GREEN_LED; HRMPLUS; NRF52840_XXAA; STATIC_AGC; AGC_FEATURE; HRV; TIA_SAT_REG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  postbuild: cmd /c "cd ..\package & makelib.cmd release AGClibM4Rel.a ..\..\sqi\iar\package\Release\libadi_vsm_sqi_m4f_Release.a ..\..\hrv\libadi_vsm_hrv_m4f.a lib_adi_vsm_hrm_m3.a lib_adi_vsm_toolbox_m3.a & del release\lib_adpd_m4.a"
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group algorithm/adi
    ../../ppg_motion_reject_algo/: adi_fixed_point_algo.c
  group ppg_lib
    ../: api_in_out.c dark_offset.c detect_motion.c detect_off.c detect_on_green.c detect_on_ir.c get_ctr_value.c heart_rate.c optimization_108.c optimization_ac.c state_machine.c utility.c
    ../../../app/nRF52840_app/: sdk_config.h
