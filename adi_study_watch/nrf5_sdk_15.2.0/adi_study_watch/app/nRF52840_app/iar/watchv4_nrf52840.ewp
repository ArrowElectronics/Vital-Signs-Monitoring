# IAR project watchv4_nrf52840.ewp, settings and files
configuration freertos (ARM)
  General.OGChipSelectEditMenu: nRF52840_xxAA NordicSemi nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; SOFTDEVICE_PRESENT; FREERTOS; NRF_SD_BLE_API_VERSION=6; S140; NRF52840_SPI_FIX; USE_USB_READ_ANY; EVTBOARD; __CORTEX_M=4; USE_FS; INITIALIZE_USER_SECTIONS; NO_VTOR_CONFIG; USE_USB_READ_ANY; ALGO_ADI; CHIPSEL_594X; CONFIG_NFCT_PINS_AS_GPIOS; DCB; PCBA; DVT; IMPEDANCE_CARTESIAN_FORM; ENAB_RTT_LOGGING; NRF_LOG_ENABLED=1; HARDFAULT_HANDLER; LOW_TOUCH_FEATURE; ENABLE_LT_TEST_PAGE
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\components\boards; ..\..\..\..\components\libraries\atomic; ..\..\..\..\components\libraries\balloc; ..\..\..\..\components\libraries\bsp; ..\..\..\..\components\libraries\delay; ..\..\..\..\components\libraries\memobj; ..\..\..\..\components\libraries\ringbuf; ..\..\..\..\components\libraries\strerror; ..\..\..\..\components\libraries\util; ..\..\..\..\components\libraries\log; ..\..\..\..\components\libraries\log\src; ..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\integration\nrfx; ..\..\..\..\integration\nrfx\legacy; ..\..\..\..\modules\nrfx; ..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\modules\nrfx\hal; ..\..\..\..\modules\nrfx\mdk; ..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\external\freertos\source\include; ..\..\..\..\external\freertos\portable\IAR\nrf52; ..\..\..\..\external\freertos\portable\CMSIS\nrf52; ..\..\..\..\components\ble\common; ..\..\..\..\components\ble\ble_advertising; ..\..\..\..\components\ble\ble_link_ctx_manager; ..\..\..\..\components\ble\nrf_ble_gatt; ..\..\..\..\components\softdevice\s140\headers; ..\..\..\..\components\libraries\atomic_flags; ..\..\..\..\components\softdevice\common; ..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\components\drivers_nrf\usbd; ..\..\..\..\components\libraries\fifo; ..\..\..\..\components\libraries\timer; ..\..\..\..\components\libraries\uart; ..\..\..\..\components\libraries\usbd; ..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\components\libraries\timer; ..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\external\utf_converter; ..\..\..\..\components\libraries\mutex; ..\..\..\..\components\libraries\button; ..\..\..\..\components\libraries\fstorage; ..\..\..\..\external\fprintf; ..\..\..\modules\adpd4000; ..\..\..\modules\adpd4000_ppg; ..\..\..\modules\adxl362; ..\..\..\modules\system; ..\..\..\modules\system\osal\free_rtos\ports; ..\..\..\modules\system\osal\free_rtos\src; ..\..\..\cli\m2m2\inc\c; ..\..\..\drivers\ad5940; ..\..\..\drivers\adpd4000; ..\..\..\drivers\adxl362; ..\..\..\drivers\adp5360; ..\..\..\utilities\circular_buffer; ..\..\..\utilities\mem_pool\; ..\..\..\utilities\memory_management\; ..\..\..\utilities\power_manager\; ..\..\..\hal; ..\..\..\app\nRF52840_app; ..\..\..\configurations; ..\..\..\utilities\tracealyser\trace_recorder\config; ..\..\..\utilities\tracealyser\trace_recorder\include; ..\..\..\utilities\tracealyser\trace_recorder\streamports\Jlink_RTT\include; ..\..\..\..\external\segger_rtt; ..\..\..\..\components\libraries\crc16; ..\..\..\utilities\lfs; ..\..\..\tst\lfs; ..\..\..\..\integration\nrfx\legacy; ..\..\..\..\modules\nrfx\drivers\include; ..\..\..\utilities\lygl; ..\..\..\button; ..\..\..\display; ..\display; ..\..\..\drivers\display; ..\..\..\drivers\button; ..\..\..\modules\ad5940_ecg; ..\..\..\drivers\pwm_reset; ..\..\..\drivers\rtc; ..\..\..\drivers\ad5940; ..\..\..\modules\adpd4000_temp; ..\..\..\drivers\wdt; ..\..\..\modules\ad5940_bcm; ..\..\..\modules\ad5940_eda; ..\..\..\..\components\libraries\block_dev; ..\..\..\..\components\libraries\pwm; ..\..\..\drivers\ad7156; ..\..\..\..\components\libraries\fds; ..\..\..\drivers\pwm_reset; ..\..\..\..\components\ble\peer_manager; ..\..\..\modules\adxl362_pedo; ..\..\..\modules\ad7156_lt; ..\..\..\modules\touch; ..\display\logical; ..\..\..\modules\test_task; ..\..\..\algo\pedometer; ..\..\..\algo\ppg_loop1_algo; ..\..\..\test_code; ..\..\..\modules\adpd4000_sqi; ..\..\..\algo\sqi\package
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10056; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA
  AARM.AUserIncludes: ..\..\..\..\components; ..\..\..\..\components\boards; ..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\components\libraries\atomic; ..\..\..\..\components\libraries\balloc; ..\..\..\..\components\libraries\bsp; ..\..\..\..\components\libraries\delay; ..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\components\libraries\log; ..\..\..\..\components\libraries\log\src; ..\..\..\..\components\libraries\memobj; ..\..\..\..\components\libraries\ringbuf; ..\..\..\..\components\libraries\strerror; ..\..\..\..\components\libraries\util; ..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\external\fprintf; ..\..\..\..\external\segger_rtt; ..\..\..\..\integration\nrfx; ..\..\..\..\integration\nrfx\legacy; ..\..\..\..\modules\nrfx; ..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\modules\nrfx\hal; ..\..\..\..\modules\nrfx\mdk; ..\config
  OBJCOPY.OOCOutputFile: watchv4.hex
  ILINK.IlinkOutputFile: watchv4.out
  ILINK.IlinkIcfFile: watchv4_nrf52840.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\algo\ppg_loop1_algo\package\debug\lib_adpd_m4_debug.a; ..\..\..\algo\pedometer\package\debug\lib_pedometer_debug.a; ..\..\..\algo\sqi\iar\package\Debug\libadi_vsm_sqi_m4f_Debug.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; SOFTDEVICE_PRESENT; FREERTOS; NRF_SD_BLE_API_VERSION=6; S140; NRF52840_SPI_FIX; USE_USB_READ_ANY; EVTBOARD; __CORTEX_M=4; USE_FS; INITIALIZE_USER_SECTIONS; NO_VTOR_CONFIG; USE_USB_READ_ANY; ALGO_ADI; CHIPSEL_594X; CONFIG_NFCT_PINS_AS_GPIOS; PCBA; DCB; DVT1; IMPEDANCE_CARTESIAN_FORM; LOW_TOUCH_FEATURE
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\components\boards; ..\..\..\..\components\libraries\atomic; ..\..\..\..\components\libraries\balloc; ..\..\..\..\components\libraries\bsp; ..\..\..\..\components\libraries\delay; ..\..\..\..\components\libraries\memobj; ..\..\..\..\components\libraries\ringbuf; ..\..\..\..\components\libraries\strerror; ..\..\..\..\components\libraries\util; ..\..\..\..\components\libraries\log; ..\..\..\..\components\libraries\log\src; ..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\integration\nrfx; ..\..\..\..\integration\nrfx\legacy; ..\..\..\..\modules\nrfx; ..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\modules\nrfx\hal; ..\..\..\..\modules\nrfx\mdk; ..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\external\freertos\source\include; ..\..\..\..\external\freertos\portable\IAR\nrf52; ..\..\..\..\external\freertos\portable\CMSIS\nrf52; ..\..\..\..\components\ble\common; ..\..\..\..\components\ble\ble_advertising; ..\..\..\..\components\ble\ble_link_ctx_manager; ..\..\..\..\components\ble\nrf_ble_gatt; ..\..\..\..\components\softdevice\s140\headers; ..\..\..\..\components\libraries\atomic_flags; ..\..\..\..\components\softdevice\common; ..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\components\drivers_nrf\usbd; ..\..\..\..\components\libraries\fifo; ..\..\..\..\components\libraries\timer; ..\..\..\..\components\libraries\uart; ..\..\..\..\components\libraries\usbd; ..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\components\libraries\timer; ..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\external\utf_converter; ..\..\..\..\components\libraries\mutex; ..\..\..\..\components\libraries\button; ..\..\..\..\components\libraries\fstorage; ..\..\..\..\external\fprintf; ..\..\..\modules\adpd4000; ..\..\..\modules\adpd4000_ppg; ..\..\..\modules\adxl362; ..\..\..\modules\system; ..\..\..\modules\system\osal\free_rtos\ports; ..\..\..\modules\system\osal\free_rtos\src; ..\..\..\cli\m2m2\inc\c; ..\..\..\drivers\ad5940; ..\..\..\drivers\adpd4000; ..\..\..\drivers\adxl362; ..\..\..\drivers\adp5360; ..\..\..\utilities\circular_buffer; ..\..\..\utilities\mem_pool\; ..\..\..\utilities\memory_management\; ..\..\..\utilities\power_manager\; ..\..\..\hal; ..\..\..\app\nRF52840_app; ..\..\..\configurations; ..\..\..\utilities\tracealyser\trace_recorder\config; ..\..\..\utilities\tracealyser\trace_recorder\include; ..\..\..\utilities\tracealyser\trace_recorder\streamports\Jlink_RTT\include; ..\..\..\..\external\segger_rtt; ..\..\..\..\components\libraries\crc16; ..\..\..\utilities\lfs; ..\..\..\tst\lfs; ..\..\..\..\integration\nrfx\legacy; ..\..\..\..\modules\nrfx\drivers\include; ..\..\..\utilities\lygl; ..\..\..\button; ..\..\..\display; ..\display; ..\..\..\drivers\display; ..\..\..\drivers\button; ..\..\..\modules\ad5940_ecg; ..\..\..\drivers\pwm_reset; ..\..\..\drivers\rtc; ..\..\..\drivers\ad5940; ..\..\..\modules\adpd4000_temp; ..\..\..\drivers\wdt; ..\..\..\modules\ad5940_bcm; ..\..\..\modules\ad5940_eda; ..\..\..\..\components\libraries\block_dev; ..\..\..\..\components\libraries\pwm; ..\..\..\drivers\ad7156; ..\..\..\..\components\libraries\fds; ..\..\..\drivers\pwm_reset; ..\..\..\..\components\ble\peer_manager; ..\..\..\modules\adxl362_pedo; ..\..\..\modules\ad7156_lt; ..\..\..\modules\touch; ..\display\logical; ..\..\..\modules\test_task; ..\..\..\algo\pedometer; ..\..\..\algo\ppg_loop1_algo; ..\..\..\test_code; ..\..\..\cli\m2m2\inc\c; ..\..\..\modules\adpd4000_sqi; ..\..\..\algo\sqi\package
  ICCARM.CCOptLevel: 2
  ILINK.IlinkAdditionalLibs: ..\..\..\algo\ppg_loop1_algo\package\release\lib_adpd_m4_release.a; ..\..\..\algo\pedometer\package\release\lib_pedometer_release.a; ..\..\..\algo\sqi\iar\package\Release\libadi_vsm_sqi_m4f_Release.a
  group (top)
    ../../../algo/sqi/package/Debug/: libadi_vsm_sqi_m4f_Debug.a
    ../../../algo/sqi/package/Release/: libadi_vsm_sqi_m4f_Release.a
  group Application
    ../../../modules/adpd4000/: adpd4000_task.c agc.c
    ../../../modules/adxl362/: adxl_task.c
    ../../../modules/ad5940_bcm/: bcm_application_task.c
    ../../../modules/system/: ble_task.c dcb_app.c file_system_task.c logger_task.c post_office.c system_task.c system_version.c usbd_task.c watch_dog_task.c
    ../../../modules/ad5940_ecg/: ecg_application_task.c
    ../../../modules/ad5940_eda/: eda_application_task.c
    ../: FreeRTOSConfig.h main_freertos.c
    ../../../modules/adxl362_pedo/: pedometer_task.c
    ../../../modules/adpd4000_ppg/: ppg_application_task.c
    ../../../modules/adpd4000_sqi/: sqi_task.c
    ../../../modules/adpd4000_temp/: temperature_task.c
    ../../../utilities/tracealyser/trace_recorder/config/: trcConfig.h trcSnapshotConfig.h trcStreamingConfig.h
  group Application/display/image
    ../display/image/: _arrows_down_ico.c _arrows_up_ico.c _battery_level_ico.c _hr_ico.c _hr_icon_small.c _hr_waveform_icon.c _low_touch_ico.c _memory_error_ico.c _memory_ico.c _memory_progress bar.c _memory_store_failure.c _memory_store_success.c _memory_turn_off_ico.c _memory_turn_on_ico.c _memory_usage_ico.c _power_on_ico.c _setting_battery_level_ico.c _setting_blue_address_ico.c _setting_brightness_adjustment_ico.c _setting_factory_reset_ico.c _setting_firmware_version_ico.c _setting_ico.c _setting_memory_error_ico.c _setting_memory_usage_ico.c _setting_power_off.c _setting_temp_ico.c _waveform_guide_ico.c _waveform_ico.c _waveform_small_ico.c
    ../display/: image_declare.h
  group Application/display/logical
    ../display/logical/: display_m2m2_protocol.c
  group Application/display/page
    ../display/: display_app.c
    ../display/page/: page_hr.c page_low_touch_logging.c page_menu.c page_power_on.c page_setting.c page_task_info.c page_waveform.c
  group Application/display/page/ble_peer
    ../display/page/ble_peer/: page_ble_peer_key.c page_ble_peer_request.c
  group Application/display/page/error_alarm
    ../display/page/error_alarm/: page_low_touch_error.c page_max_file_alarm.c page_no_battery_error.c
  group Application/display/page/heart_rate
    ../display/page/heart_rate/: page_bpm.c
  group Application/display/page/low_touch_logging
    ../display/page/low_touch_logging/: page_low_touch_config.c page_low_touch_logging_status.c
  group Application/display/page/low_voltage_protect
    ../display/page/low_voltage_protect/: page_low_voltage_alarm.c
  group Application/display/page/setting
    ../display/page/setting/: page_battery_level.c page_blue_address.c page_brightness_switch.c page_firmware_version.c page_memory_usage.c page_power_off.c page_power_off_confirm.c page_shipment_mode.c page_shipment_mode_confirm.c
  group Application/display/page/temp_protect
    ../display/page/tmp_protect/: page_tmp_high_alarm.c page_tmp_low_alarm.c
  group Application/display/page/test
    ../display/page/test/: page_test_backlight.c page_test_lt.c page_test_touch.c
  group Application/display/page/waveform
    ../display/page/waveform/: page_ecg.c page_ecg_title.c page_ppg.c page_ppg_title.c page_skin_temp.c page_skin_temp_tile.c
  group Application/HardFault
    ../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../../../components/libraries/hardfault/: hardfault_implementation.c
  group Application/low_touch_app
    ../../../modules/ad7156_lt/: dcb_general_block.c low_touch_task.c wrist_detect_block.c
  group Application/test_code
    ../../../test_code/: rtos_test.c us_tick.c
  group Application/test_items
    ../../../modules/test_task/: key_test.c touch_test.c
  group Application/touch
    ../../../modules/touch/: touch_detect.c
  group Board Definition
    ../../../../components/boards/: boards.c
  group Board Support
    ../../../../components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group HWIF
    ../../../hal/: hal_gpio.c hal_i2c.c hal_spi.c hal_twi0.c hal_uart.c
  group Middleware/FreeRTOS/Portable
    ../../../../external/freertos/portable/IAR/nrf52/: port.c
  group Middleware/FreeRTOS/Portable/CMSIS
    ../../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group Middleware/FreeRTOS/Portable/MemMgmt
    ../../../../external/freertos/source/portable/MemMang/: heap_1.c
  group Middleware/FreeRTOS/Source
    ../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware/Mailbox
    ../../../modules/system/: mail_box.c
  group Middleware/MemMgmt
    ../../../utilities/memory_management/: memory_management.c
  group Middleware/OSAL/PORTS
    ../../../modules/system/osal/free_rtos/ports/: adi_osal_arch_c.c adi_osal_arch_int_table.c adi_osal_FreeRTOS_arch_c.c
  group Middleware/OSAL/SOURCE
    ../../../modules/system/osal/free_rtos/src/: adi_osal_freertos.c adi_osal_freertos_critical.c adi_osal_freertos_event.c adi_osal_freertos_init.c adi_osal_freertos_message.c adi_osal_freertos_mutex.c adi_osal_freertos_rtl_lock.c adi_osal_freertos_sem.c adi_osal_freertos_thread.c adi_osal_freertos_thread_queue.c adi_osal_freertos_timing.c adi_osal_freertos_tls.c
  group Middleware/PPG
    ../../../modules/adpd4000_ppg/: app_common.c app_sync.c mw_ppg.c struct_operations.c sync_data_buffering.c
  group nRF_BLE
    ../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../../../../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../../components/libraries/fds/: fds.c
    ../../../../components/libraries/block_dev/qspi/: nrf_block_dev_qspi.c
    ../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_ppi.c nrf_drv_rng.c nrf_drv_spi.c nrf_drv_twi.c nrf_drv_uart.c
    ../../../../components/drivers_nrf/usbd/: nrf_drv_usbd.c
    ../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_power_clock.c nrfx_ppi.c nrfx_pwm.c nrfx_qspi.c nrfx_rtc.c nrfx_spi.c nrfx_spim.c nrfx_timer.c nrfx_twi.c nrfx_twim.c nrfx_uart.c nrfx_uarte.c nrfx_wdt.c
    ../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../components/libraries/button/: app_button.c
    ../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../components/libraries/fifo/: app_fifo.c
    ../../../../components/libraries/pwm/: app_pwm.c
    ../../../../components/libraries/timer/: app_timer_freertos.c
    ../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../../../../components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../../../../components/libraries/crc16/: crc16.c
    ../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../components/libraries/block_dev/qspi/: nrf_serial_flash_params.c
    ../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_SoftDevice
    ../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_freertos.c nrf_sdh_soc.c
  group SensorDrivers/AD5940
    ../../../drivers/ad5940/: ad5940.c ad5940_buffering.c sensor_ad5940.h
  group SensorDrivers/AD7156
    ../../../drivers/ad7156/: ad7156.c ad7156_dcfg.c
  group SensorDrivers/adi_fs
    ../../../modules/system/: fds_drv.c
  group SensorDrivers/ADP5360
    ../../../drivers/adp5360/: adp5360.c low_voltage_protect.c
  group SensorDrivers/ADPD4000
    ../../../drivers/adpd4000/: adpd4000_buffering.c adpd4000_dcfg.c adpd400x_drv.c lcm.c
  group SensorDrivers/ADXL
    ../../../drivers/adxl362/: adxl362.c adxl_buffering.c adxl_dcfg.c adxl_drv.c
  group SensorDrivers/button_display
    ../../../drivers/button/: key_detect.c
    ../../../drivers/display/: lcd_driver.c
  group SensorDrivers/LFS
    ../../../utilities/lfs/: nand_cmd.c nand_functions.c
  group SensorDrivers/pwm_reset
    ../../../drivers/pwm_reset/: pwm_reset.c
  group SensorDrivers/rtc
    ../../../hal/: adi_calendar.c
    ../../../drivers/rtc/: m_time.c rtc.c
  group SensorDrivers/wdt
    ../../../drivers/wdt/: wdt.c
  group Startup
    ./: iar_startup_nrf52840.s
    ../: system_nrf52840.c
  group UTF8/UTF16 converter
    ../../../../external/utf_converter/: utf.c
  group Utilities
    ../../../modules/system/: printf.c
  group Utilities/ADPD4000
    ../../../modules/adpd4000/: clock_calibration.c dark_offset.c float_mode.c get_ctr_value.c normal_mode.c utility.c
  group Utilities/CircularBuffer
    ../../../utilities/circular_buffer/: circular_buffer.c
  group Utilities/DCB
    ../../../modules/system/: adi_dcb_config.c
  group Utilities/LFS
    ../../../utilities/lfs/: file_system_utils.c light_fs.c
  group Utilities/lygl
    ../../../utilities/lygl/: lygl_battry_level.c lygl_common.c lygl_graph.c lygl_image.c lygl_process_bar.c lygl_text.c
  group Utilities/lygl/font
    ../../../utilities/lygl/font/: weiruanyahei24.c weiruanyahei32.c weiruanyahei47.c weiruanyahei48.c weiruanyahei62.c weiruanyahei64.c
  group Utilities/MemPool
    ../../../utilities/mem_pool/: mem_pool.c
  group Utilities/Power
    ../../../utilities/power_manager/: power_manager.c power_on_detect.c
  group Utilities/Tracealyser
    ../../../utilities/tracealyser/trace_recorder/include/: trcHardwarePort.h trcKernelPort.h trcPortDefines.h trcRecorder.h
    ../../../utilities/tracealyser/trace_recorder/: trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c
    ../../../utilities/tracealyser/trace_recorder/streamports/Jlink_RTT/: trcStreamingPort.c
