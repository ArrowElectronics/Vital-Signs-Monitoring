<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\algo\pedometer\iar\pedometer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\watchv4_nrf52840.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\algo\ppg_loop1_algo\iar\heart_rate_coolidge.ewp</path>
    </project>
    <batchBuild />
</workspace>
