# IAR project EDA_App_Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52840_xxAA NordicSemi nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; SOFTDEVICE_PRESENT; FREERTOS; NRF_SD_BLE_API_VERSION=6; S140; NRF52840_SPI_FIX; INITIALIZE_USER_SECTIONS; NO_VTOR_CONFIG; USE_USB_READ_ANY; ALGO_ADI; EVTBOARD; USE_FS; CHIPSEL_594X; CONFIG_NFCT_PINS_AS_GPIOS; DCB; BLOCKING_CALL; IMPEDANCE_CARTESIAN_FORM
  ICCARM.CCIncludePath2: ..\..\..\..\components\boards; ..\..\..\..\components\libraries\atomic; ..\..\..\..\components\libraries\balloc; ..\..\..\..\components\libraries\bsp; ..\..\..\..\components\libraries\delay; ..\..\..\..\components\libraries\memobj; ..\..\..\..\components\libraries\ringbuf; ..\..\..\..\components\libraries\strerror; ..\..\..\..\components\libraries\util; ..\..\..\..\components\libraries\log; ..\..\..\..\components\libraries\pwm; ..\..\..\..\components\libraries\log\src; ..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\integration\nrfx; ..\..\..\..\integration\nrfx\legacy; ..\..\..\..\modules\nrfx; ..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\modules\nrfx\hal; ..\..\..\..\modules\nrfx\mdk; ..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\components\ble\common; ..\..\..\..\components\ble\ble_advertising; ..\..\..\..\components\ble\common; ..\..\..\..\components\ble\ble_link_ctx_manager; ..\..\..\..\components\ble\nrf_ble_gatt; ..\..\..\..\components\softdevice\s140\headers; ..\..\..\..\components\libraries\atomic_flags; ..\..\..\..\components\softdevice\common; ..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\components\drivers_nrf\usbd; ..\..\..\..\components\libraries\fifo; ..\..\..\..\components\libraries\timer; ..\..\..\..\components\libraries\uart; ..\..\..\..\components\libraries\usbd; ..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\components\libraries\timer; ..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\external\utf_converter; ..\..\..\..\components\libraries\mutex; ..\..\..\..\components\libraries\button; ..\..\..\..\components\libraries\fstorage; ..\..\..\..\external\fprintf; ..\..\..\..\external\freertos\source\include; ..\..\..\..\external\freertos\portable\IAR\nrf52; ..\..\..\..\external\freertos\portable\CMSIS\nrf52; ..\..\..\modules\adpd4000; ..\..\..\modules\adpd4000_ppg; ..\..\..\modules\adxl362; ..\..\..\modules\ad5940_ecg; ..\..\..\modules\system; ..\..\..\modules\system\osal\free_rtos\ports; ..\..\..\modules\system\osal\free_rtos\src; ..\..\..\cli\m2m2\inc\c; ..\..\..\drivers\ad5940; ..\..\..\drivers\adpd4000; ..\..\..\drivers\adxl362; ..\..\..\drivers\adp5360; ..\..\..\drivers\button; ..\..\..\drivers\display; ..\..\..\utilities\circular_buffer; ..\..\..\utilities\mem_pool; ..\..\..\utilities\memory_management; ..\..\..\utilities\power_manager; ..\..\..\utilities\lygl\font; ..\..\..\hal; ..\..\..\utilities\lygl; ..\..\..\configurations; ..\..\..\app\nRF52840_app; ..\..\..\..\external\segger_rtt; ..\..\..\app\nRF52840_app\display; ..\..\..\modules\ad5940_eda; ..\..\..\modules\ad5940_bcm; ..\app_files; ..\..\..\drivers\rtc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EDA_App_Test.hex
  ILINK.IlinkOutputFile: EDA_App_Test.out
  ILINK.IlinkIcfFile: C:\Work\PortingtoSegger\EDA_Start_Stop_Issue\study_watch\nrf5_sdk_15.2.0\adi_study_watch\tst\ad5940_eda\iar\EDA_App_Test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group AppFiles
    ../app_files/: EDA_App_Test.c Main.c
    ../../../app/nRF52840_app/: FreeRTOSConfig.h
    ../../../modules/system/: logger_task.c
  group Drivers/AD5940
    ../../../drivers/ad5940/: ad5940.c sensor_ad5940.h
    ../../../hal/: hal_i2c.c
  group Drivers/ADP5360
    ../../../drivers/adp5360/: adp5360.c
  group Drivers/wdt
    ../../../drivers/wdt/: wdt.c
  group HardFault
    ../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../../../components/libraries/hardfault/: hardfault_implementation.c
  group Middleware/FreeRTOS/Portable
    ../../../../external/freertos/portable/IAR/nrf52/: port.c
  group Middleware/FreeRTOS/Portable/CMSIS
    ../../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group Middleware/FreeRTOS/Portable/MemMgmt
    ../../../../external/freertos/source/portable/MemMang/: heap_1.c
  group Middleware/FreeRTOS/Source
    ../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware/OSAL/PORTS
    ../../../modules/system/osal/free_rtos/ports/: adi_osal_arch_c.c adi_osal_arch_int_table.c adi_osal_free_rtos_arch_c.c
  group Middleware/OSAL/SOURCE
    ../../../modules/system/osal/free_rtos/src/: adi_osal_freertos.c adi_osal_freertos_critical.c adi_osal_freertos_event.c adi_osal_freertos_init.c adi_osal_freertos_message.c adi_osal_freertos_mutex.c adi_osal_freertos_rtl_lock.c adi_osal_freertos_sem.c adi_osal_freertos_thread.c adi_osal_freertos_thread_queue.c adi_osal_freertos_timing.c adi_osal_freertos_tls.c
  group nRF_BLE
    ../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../../../../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_ppi.c nrf_drv_spi.c nrf_drv_twi.c nrf_drv_uart.c
    ../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_power_clock.c nrfx_ppi.c nrfx_pwm.c nrfx_spi.c nrfx_spim.c nrfx_timer.c nrfx_twi.c nrfx_twim.c nrfx_uart.c nrfx_uarte.c nrfx_wdt.c
    ../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../components/libraries/button/: app_button.c
    ../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c
    ../../../../components/libraries/fifo/: app_fifo.c
    ../../../../components/libraries/pwm/: app_pwm.c
    ../../../../components/libraries/timer/: app_timer_freertos.c
    ../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../../../../components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_SoftDevice
    ../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_freertos.c nrf_sdh_soc.c
  group Startup
    ../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group UTF8/UTF16 converter
    ../../../../external/utf_converter/: utf.c
  group Utilities/Power
    ../../../utilities/power_manager/: power_manager.c
